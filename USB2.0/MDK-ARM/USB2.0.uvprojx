# Keil uVision project USB2.0.uvprojx, settings and files
target USB2.0 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: USB2.0 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G030xx
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;.\OLED;.\ADC;..\Drivers\STM32G0xx_HAL_Driver\Inc;..\Drivers\STM32G0xx_HAL_Driver\Inc\Legacy;.\menu;.\Key;.\Timer;.\Delay;.\Wire
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
    ./: startup_stm32g030xx.s
  group OLED
    ./OLED/: oled.c
  group ADC
    ./ADC/: ADC.c
  group menu
    ./menu/: menu_gui.c menu.c
  group Key
    ./Key/: Key.c
  group Timer
    ./Timer/: Timer.c
  group Delay
    ./Delay/: Delay.c
  group Wire
    ./Wire/: AT24C32.c Wire.c
software components: CMSIS:CORE 4.3.0
